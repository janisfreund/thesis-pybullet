Commit message: Add search and rescue

File: models/office/office.urdf (robot description, URDF)
Before this commit: robot car, 1 links, 0 joints
Links:
- link base: geometry collision mesh filename=package://office/office_no_doors.obj; visual mesh filename=package://office/office_no_doors.obj
